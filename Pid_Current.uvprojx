# Keil uVision project Pid_Current.uvprojx, settings and files
target WHOLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pid_Current
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, ARM_MATH_CM3, STM32F10X_CL
  c include: .\RTE\_Target_1;.\RTE\Device;.\RTE\Device\STM32F105RB;.\DSP;.\USER;.\CONTROL;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/: Can.c nvic.c
  group DSP
    ./DSP/: FIR.c
  group CONTROL
    ./CONTROL/: Pid.c Motor_Task.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
